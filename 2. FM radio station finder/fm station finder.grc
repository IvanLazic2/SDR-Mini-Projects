options:
  parameters:
    generate_options: qt_gui
    id: fm_station_finder
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_gain_slider
  id: variable_qtgui_range
  parameters:
    label: Audio gain
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 98e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: current_freq
  id: variable
  parameters:
    value: 95.8e6
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: (1, 0, 1, 1)
    label: 'Station:'
    type: real
    value: current_freq
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq - current_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: current_freq
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain_slider
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from scipy.signal import find_peaks
      from gnuradio import gr
      import pmt 

      from collections import Counter

      class StationFinder(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="station_finder",
                  in_sig=[(np.float32, 1024)],
                  out_sig=[]
              )

              self.fft_size = 1024
              self.samp_rate = 20e6
              self.center_freq = 98e6
              self.frames_per_scan = 20000  # 1 sec at 20k vectors/sec
              self.accumulator = np.zeros(self.fft_size, dtype=np.float64)
              self.frame_count = 0

              self.station_freqs = []
              self.last_station_freqs = []

              self.message_port_register_out(pmt.intern("stations_out"))

          def work(self, input_items, output_items):
              in0 = input_items[0]
              n = len(in0)

              for i in range(n):
                  self.accumulator += in0[i]
                  self.frame_count += 1

                  if self.frame_count >= self.frames_per_scan:
                      avg_spectrum = self.accumulator / self.frames_per_scan
                      self.accumulator[:] = 0
                      self.frame_count = 0

                      center_bin = self.fft_size // 2
                      avg_spectrum[center_bin-2:center_bin+3] = 0

                      norm_spectrum = avg_spectrum / np.max(avg_spectrum)

                      peaks, _ = find_peaks(
                          norm_spectrum,
                          #    P_dB = 10 * log10(P_linear)
                          # => P_linear = 10 ** (p_dB / 10)
                          # Noise: -71dB
                          # Weak: -67dB => 4dB above noise
                          # Strong: -49dB
                          prominence=0.05, # 0.07
                          distance=20
                      )

                      if len(peaks) > 0:
                          freqs = np.linspace(
                              self.center_freq - self.samp_rate / 2,
                              self.center_freq + self.samp_rate / 2,
                              self.fft_size
                          )
                          peak_freqs = freqs[peaks]
                          peak_freqs_khz = np.round(peak_freqs / 1000) * 1000

                          self.last_station_freqs = self.station_freqs
                          self.station_freqs = np.unique(peak_freqs_khz.astype(np.float32))

                          if Counter(self.last_station_freqs) == Counter(self.station_freqs):
                              break

                          self.station_freqs = np.sort(self.station_freqs)

                          pmt_msg = pmt.init_f32vector(len(self.station_freqs), self.station_freqs)
                          self.message_port_pub(pmt.intern("stations_out"), pmt_msg)

              return n
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nfrom collections import Counter\n\nclass station_handler(gr.basic_block):\n    def __init__(self):\n        gr.basic_block.__init__(self,\n            name=\"station_handler\",\n            in_sig=None,\n            out_sig=None)\n\n        self.message_port_register_in(pmt.intern(\"stations_in\"))\n        self.set_msg_handler(pmt.intern(\"stations_in\"), self.handle_stations)\n\n        self.message_port_register_in(pmt.intern(\"cmd_in\"))\n        self.set_msg_handler(pmt.intern(\"cmd_in\"), self.handle_command)\n\n        self.stations = []\n        self.last_stations = []\n        self.current_index = 0\n\n        self.current_freq = 0\n        self.last_freq = 0\n\n        self.message_port_register_out(pmt.intern(\"freq_out\"))\n\n\n    def handle_stations(self, msg):\n        if pmt.is_f32vector(msg):\n            freqs = sorted(set(pmt.to_python(msg)))\n        else:\n            return\n\n        if not freqs:\n            return\n\n        self.last_freq = self.current_freq\n        self.current_freq = self.stations[self.current_index] if self.stations else None\n\n        self.last_stations = self.stations\n        self.stations = freqs\n\n        if Counter(self.last_stations) == Counter(self.stations):\n            return\n\n        if self.last_freq == self.current_freq:\n            return\n\n        if self.current_freq in self.stations:\n            self.current_index = self.stations.index(self.current_freq)\n        \n        if self.current_index >= len(self.stations):\n            return\n        \n        self.set_freq(self.stations[self.current_index])\n\n\n    def handle_command(self, msg):\n        if pmt.is_pair(msg):\n            key = pmt.symbol_to_string(pmt.car(msg))\n            val = pmt.cdr(msg)\n\n            if key == \"cmd\":\n                if pmt.is_symbol(val):\n                    cmd = pmt.symbol_to_string(val)\n                elif pmt.is_string(val):\n                    cmd = pmt.to_python(val)\n                else:\n                    return\n\n                if cmd == \"next\":\n                    self.step_next()\n                elif cmd == \"prev\":\n                    self.step_prev()\n\n\n    def step_next(self):\n        if not self.stations:\n            return\n        self.current_index = (self.current_index + 1) % len(self.stations)\n        self.set_freq(self.stations[self.current_index])\n\n    def step_prev(self):\n        if not self.stations:\n            return\n        self.current_index = (self.current_index - 1) % len(self.stations)\n        self.set_freq(self.stations[self.current_index])\n\n\n    def set_freq(self, freq):\n        msg = pmt.cons(pmt.intern(\"freq\"), pmt.from_double(freq))\n        self.message_port_pub(pmt.intern(\"freq_out\"), msg)\n        print(f\"Station {self.current_index + 1}/{len(self.stations)}: {freq / .1e7} MHz\")\n\n    def get_freq(self):\n        return self.current_freq\n\n\n"
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: int(samp_rate / channel_width)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: next_button
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: (0, 1, 1, 1)
    label: Next
    msgName: cmd
    relBackgroundColor: navy
    relFontColor: white
    type: string
    value: next
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: prev_button
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: (0,0,1,1)
    label: Previous
    msgName: cmd
    relBackgroundColor: navy
    relFontColor: white
    type: string
    value: prev
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: fft_size
    type: complex
    update_time: '0.025'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, stations_out, blocks_message_debug_0, print]
- [epy_block_0, stations_out, epy_block_1, stations_in]
- [epy_block_1, freq_out, blocks_msgpair_to_var_0, inpair]
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [next_button, pressed, epy_block_1, cmd_in]
- [osmosdr_source_0, '0', blocks_throttle2_0, '0']
- [prev_button, pressed, epy_block_1, cmd_in]
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
